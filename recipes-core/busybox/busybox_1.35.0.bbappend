FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:m28evk = " file://nc.cfg "
SRC_URI:append:m53evk = " file://nc.cfg "
SRC_URI:append:mcvevk = " file://nc.cfg "
SRC_URI:append:ma5d4evk = " file://nc.cfg "
