FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_m28evk = " file://nc.cfg "
SRC_URI_append_m53evk = " file://nc.cfg "
SRC_URI_append_mcvevk = " file://nc.cfg "
SRC_URI_append_ma5d4evk = " file://nc.cfg "
