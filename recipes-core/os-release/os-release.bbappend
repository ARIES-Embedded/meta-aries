OS_RELEASE_FIELDS="ID NAME VERSION BUILD_ID"
